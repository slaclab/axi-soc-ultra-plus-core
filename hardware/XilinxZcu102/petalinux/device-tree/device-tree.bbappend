YAML_DT_BOARD_FLAGS = "{BOARD zcu102-reva}"
