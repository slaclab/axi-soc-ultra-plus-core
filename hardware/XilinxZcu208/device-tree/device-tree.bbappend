YAML_DT_BOARD_FLAGS = "{BOARD zcu208}"
