YAML_DT_BOARD_FLAGS = "{BOARD zynqmp-smk-k26-reva}"
