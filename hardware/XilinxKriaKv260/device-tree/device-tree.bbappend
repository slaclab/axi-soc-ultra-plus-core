YAML_DT_BOARD_FLAGS = "{BOARD k26-som}"
